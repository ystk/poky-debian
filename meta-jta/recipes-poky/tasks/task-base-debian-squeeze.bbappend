DEBIAN_SQUEEZE_EXTRA_RDEPENDS_append = " \
openssh-ssh \
openssh-sshd \
openssh-scp \
bash \
bc \
"
