FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://replace_BLK_TC_BARRIER.patch"
