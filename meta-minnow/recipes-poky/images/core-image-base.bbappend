# additional device files
IMAGE_DEVICE_TABLES += " \
files/device-table/mmcblk0.txt \
files/device-table/tty.txt \
files/device-table/ttyS.txt \
files/device-table/ttyPCH.txt \
files/device-table/pts.txt \
files/device-table/sda.txt \
files/device-table/compat.txt \
"
