# exclude "task-net-busybox" to remove udhcpc scripts
RDEPENDS_task-base-debian-squeeze = "${DEBIAN_SQUEEZE_EXTRA_RDEPENDS}"
