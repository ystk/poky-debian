IMAGE_DEVICE_TABLES += " \
files/device-table/mmcblk0.txt \
files/device-table/tty.txt \
files/device-table/ttyO2.txt \
"
