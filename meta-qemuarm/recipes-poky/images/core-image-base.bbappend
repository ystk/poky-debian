IMAGE_DEVICE_TABLES += " \
files/device-table/sda.txt \
files/device-table/tty.txt \
files/device-table/ttyAMA.txt \
"
