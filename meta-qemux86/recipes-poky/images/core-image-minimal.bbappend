IMAGE_DEVICE_TABLES = " \
files/device-table/minimal.txt \
files/device-table/sda.txt \
files/device-table/tty.txt \
"
