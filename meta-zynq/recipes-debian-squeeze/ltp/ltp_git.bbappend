FILES_${PN} += "${bindir}/execltp "
