# TBD
DEBIAN_SQUEEZE_EXTRA_RDEPENDS += " \
trace-cmd \
htop \
procps \
rt-tests \
mtd-utils \
module-init-tools \
busybox \
ltp \
rt-tests \
openssh-ssh \
openssh-scp \
openssh-sshd \
openssh-keys \
lm-sensors \
rsync \
e2fsprogs-mke2fs \
"
