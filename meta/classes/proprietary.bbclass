LICENSE = "PROPRIETARY"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/COPYING.PROPRIETARY;md5=38c9703cfb4dea81c34da41b32913aed"
