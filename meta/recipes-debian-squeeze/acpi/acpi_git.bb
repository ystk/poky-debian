#
# debian-squeeze 
#
DESCRIPTION = "displays information on ACPI devices"
HOMEPAGE = "http://sourceforge.net/projects/acpiclient"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"
SECTION = "utils"
PR = "r0"

inherit autotools
inherit debian-squeeze
