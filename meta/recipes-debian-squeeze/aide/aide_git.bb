DESCRIPTION = "Advanced Intrusion Detection Environment"
HOMEPAGE = "http://aide.sourceforge.net/"
SECTION = "admin"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=c93c0550bd3173f4504b2cbd8991e50b"

inherit autotools
inherit debian-squeeze

