#
# debian-squeeze
#
DESCRIPTION = "tool for resizing BDF format font"
SECTION = "x11"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"
PR = "r0"

inherit autotools
inherit debian-squeeze

