#
# boost-jam-native_3.1.18.bb
#

include boost-jam-native.inc

#SRC_URI = "${SOURCEFORGE_MIRROR}/boost/boost-jam-${PV}.tgz"

#
# debian-squeeze
#

inherit debian-squeeze

PR = "r0"
