require cyrus-sasl2_${PV}.bb

PR = "r0"

DEPENDS = "binutils-native"
PACKAGES = ""

inherit native
