#
# debian-squeeze
#
DESCRIPTION = "Syslog event logger"
SECTION = "libs"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=b8ba8e77bcda9a53fac0fe39fe957767"
PR = "r0"

inherit autotools gettext
inherit debian-squeeze
