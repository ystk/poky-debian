require gcc-linaro-cross_${PV}.bb
require gcc-linaro-cross-initial.inc

