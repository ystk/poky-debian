require gcc-linaro-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc
