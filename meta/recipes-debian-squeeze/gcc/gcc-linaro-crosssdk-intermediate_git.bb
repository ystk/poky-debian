require gcc-linaro-cross-intermediate_${PV}.bb
require gcc-crosssdk-intermediate.inc
