require gcc-linaro-cross_${PV}.bb
require gcc-crosssdk.inc
