require gcc-linaro-${PV}.inc
require libgcc-linaro.inc
