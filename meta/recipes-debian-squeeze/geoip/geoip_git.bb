DESCRIPTION = "GeoIP is a C library that enables the user to find the country \
that any IP address or hostname originates from. It uses a file based database."

SECTION = "net"
LICENSE = "GPLv2.1"
LIC_FILES_CHKSUM = "file://COPYING;md5=d5d53d6b948c064f4070183180a4fa89"

inherit autotools debian-squeeze
