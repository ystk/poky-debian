#
# debian-squeeze
#
DESCRIPTION = "GNU privacy guard - a free PGP replacement"
HOMEPAGE = "http://www.gnupg.org"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://COPYING;md5=f27defe1e96c2e1ecd4e0c9be8967949"
SECTION = "console/utils"
PR = "r0"

inherit autotools gettext
inherit debian-squeeze

