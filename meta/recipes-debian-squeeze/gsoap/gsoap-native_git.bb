require gsoap_${PV}.inc

DEPENDS = ""

EXTRA_OEMAKE = ""

inherit native


