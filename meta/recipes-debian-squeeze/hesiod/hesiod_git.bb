#
# debian-squeeze
#

DESCRIPTION = " Project Athena's DNS-based directory service - utilities"
SECTION = "libs"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://README;md5=5915116b463a5ea827ac3d20047b148f"

inherit debian-squeeze
inherit autotools

PR = "r0"
