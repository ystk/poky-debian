require icu.inc
PR = "r0"
inherit native

BBCLASSEXTEND = "native"
