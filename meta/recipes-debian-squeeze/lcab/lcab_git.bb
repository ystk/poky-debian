#
# Debian
#

DESCRIPTION = "Create cabinet (.cab) archives"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=393a5ca445f6965873eca0259a17f833"
SECTION = "utils"
PR = "r0"

inherit autotools
inherit debian-squeeze
