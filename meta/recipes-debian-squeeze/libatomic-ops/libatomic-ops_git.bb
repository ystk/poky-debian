#
# debian-squeeze
#
DESCRIPTION = "A library for atomic operations (development files)"
SECTION = "libdevel"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"
PR = "r0"

inherit autotools gettext
inherit debian-squeeze
