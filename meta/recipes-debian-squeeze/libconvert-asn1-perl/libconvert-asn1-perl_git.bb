#
# debian-squeeze
#

DESCRIPTION = "Perl module for encoding and decoding ASN.1 data structures"
SECTION = "perl"
LICENSE = "GPL-1.0+ & Artistic"
LIC_FILES_CHKSUM = "file://README;md5=8330a7f037f4d27c2f8b4e406b32b920"
PR = "r0"

inherit debian-squeeze
inherit cpan
