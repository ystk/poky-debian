#
# debian-squeeze
#
DESCRIPTION = "Double-array trie library"
HOMEPAGE = "http://libthai.sourceforge.net"
LICENSE = "GPLv2 & LGPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=2d5025d4aa3495befef8f17206a5b0a1"
SECTION = "libs"
PR = "r0"

inherit autotools
inherit debian-squeeze native
