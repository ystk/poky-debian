#
# debian-squeeze
#
DESCRIPTION = "configuration file parser library for dsh - runtime"
SECTION = "libs"
LICENSE = "GPL-2"
LIC_FILES_CHKSUM = "file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"

inherit debian-squeeze autotools
