#
# debian-squeeze 
#
DESCRIPTION = "GD command line tools and example code "
SECTION = "graphic"                      
LICENSE = "GPLv2+ & BSD"                                                              
LIC_FILES_CHKSUM = "file://COPYING;md5=c97638cafd3581eb87abd37332137669"        
PR = "r0"                                                                       

inherit autotools                                                              
inherit debian-squeeze
