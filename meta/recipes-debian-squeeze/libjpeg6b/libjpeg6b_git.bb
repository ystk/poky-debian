
#
# debian-squeeze
#
DESCRIPTION = "The Independent JPEG Group's JPEG runtime library (version 6.2)"
SECTION = "graphics"
LICENSE = "JPEG"
LIC_FILES_CHKSUM = "file://README;md5=b2c4ba2a8ce80468db498a6b331f900d"


inherit debian-squeeze
inherit autotools
DEPENDS += ""
