#
# debian-squeeze
#
DESCRIPTION = "Perl module to parse and convert to JSON"
HOMEPAGE = "http://search.cpan.org/dist/JSON/"
SECTION = "perl"
LICENSE = "GPL-1+"
LIC_FILES_CHKSUM = "file://README;md5=fe828f7850372ec16b549806cdb115fb"

inherit debian-squeeze
inherit cpan
