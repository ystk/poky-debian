#
# debian-squeeze
#
DESCRIPTION = "Manipulate email in perl programs \
This is a set of perl modules which provide an easy interface to \
manipulating email in an object-oriented fashion."

SECTION = "mail"
HOMEPAGE = "http://search.cpan.org/dist/MailTools/"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://README;md5=cb4a7c1ce73597b24b206f42af536546"
PR = "r0"

inherit debian-squeeze cpan
