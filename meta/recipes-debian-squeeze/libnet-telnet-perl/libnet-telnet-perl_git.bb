#
# debian-squeeze
#

DESCRIPTION = "Script telnetable connections"
HOMEPAGE = "http://search.cpan.org/dist/Net-Telnet"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://README;md5=4d84fe343b1b918f29f08c0775ea943c"
SECTION = "perl"
PR = "r0"

inherit debian-squeeze
inherit cpan
