#
# debian-squeeze
#
DESCRIPTION = "Netfilter netlink library"
HOMEPAGE = "http://www.netfilter.org/downloads.html"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://README;md5=287b7901363dda6ef7176fadee6972ed"
SECTION = "libs"
PR = "r0"

inherit autotools
inherit debian-squeeze
