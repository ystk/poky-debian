DESCRIPTION = "Oniguruma regular expressions library"
SECTION = "libs"
LICENSE = " BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=0d4861b5bc0c392a5aa90d9d76ebd86f"

inherit debian-squeeze autotools
