#
# debian-squeeze
#

DESCRIPTION = "internationalized substitute of Text::Wrap"
SECTION = "perl"
LICENSE = "Artistic & GPL"
LIC_FILES_CHKSUM = "file://README;md5=080862e1e40cdcddef4393e137285858"

inherit debian-squeeze
inherit cpan
