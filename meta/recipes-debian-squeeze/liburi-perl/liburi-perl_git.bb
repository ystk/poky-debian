#
# debian-squeeze
#
DESCRIPTION = "module to manipulate and access URI strings \
URI is a collection of Perl modules that represent and manipulate Uniform \
Resource Identifier (URI) references as specified in RFC 2396."
SECTION = "perl"
HOMEPAGE = "http://search.cpan.org/dist/URI/"
LICENSE = "GPL-1+"
LIC_FILES_CHKSUM = "file://MANIFEST;md5=67478e7d6ca32e7a379c0099890ab123"
PR = "r0"

inherit debian-squeeze cpan
