#
# debian-squeeze
#

DESCRIPTION = "A privileged helper for utmp/wtmp updates (development)"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=2d5025d4aa3495befef8f17206a5b0a1"

inherit autotools gettext

inherit  debian-squeeze
