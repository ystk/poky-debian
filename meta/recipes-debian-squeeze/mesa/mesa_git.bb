DESCRIPTION = "free implementation of the OpenGL API"
SECTION = "libs"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://Makefile;md5=14c423c098ee87d7d674806eb30a5610"


#
# debian-squeeze
#
inherit debian-squeeze
inherit autotools
DEPENDS += ""
