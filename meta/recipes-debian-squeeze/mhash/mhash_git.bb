#
# debian-squeeze
#

DESCRIPTION = "Library for cryptographic hashing and message authentication"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"
PR = "r1"

inherit autotools gettext

inherit debian-squeeze
