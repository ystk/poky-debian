#
# debian-squeeze
#

DESCRIPTION = "An HTTP and WebDAV client library"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://README;md5=7d62859e362706308321ef896486d755"
SECTION = "net"
PR = "r0"

inherit autotools
inherit debian-squeeze

