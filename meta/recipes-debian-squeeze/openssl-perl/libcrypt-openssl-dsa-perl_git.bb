#
# debian-squeeze
#

DESCRIPTION = "module which implements the DSA signature verification system"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://README;md5=d1604d3ae6643cc52728f460eca940ba"

require libcrypt-openssl-perl.inc
