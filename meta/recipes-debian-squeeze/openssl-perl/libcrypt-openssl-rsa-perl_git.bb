#
# debian-squeeze
#

DESCRIPTION = "Perl module providing basic RSA functionality"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://LICENSE;md5=385c55653886acac3821999a3ccd17b3"

require libcrypt-openssl-perl.inc
