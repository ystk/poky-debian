#
# debian-squeeze
#

DESCRIPTION = "Library of Optimized Inner Loops Runtime Compiler"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=1400bd9d09e8af56b9ec982b3d85797e"
SECTION = "devel"
PR = "r0"

inherit autotools
inherit debian-squeeze

