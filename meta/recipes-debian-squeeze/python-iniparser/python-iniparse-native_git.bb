#
# debian-squeeze
# 

require python-iniparse_${PV}.bb
inherit native
DEPENDS = "python2.6-native"
RDEPENDS = ""
PR = "r0"
