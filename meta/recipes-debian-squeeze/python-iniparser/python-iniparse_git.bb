#
# debian-squeeze
#

DESCRIPTION = "Module to access and modify configuration data in INI files"
HOMEPAGE = "http://code.google.com/p/iniparse/"
SECTION = "python"
PRIORITY = "extra"
LICENSE = "GPLv2+"
PR = "r0"

inherit distutils
inherit debian-squeeze

LIC_FILES_CHKSUM = "file://LICENSE;md5=52f28065af11d69382693b45b5a8eb54"
