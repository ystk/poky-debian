DESCRIPTION = "QDBM Database Libraries"
SECTION = "libs"
LICENSE = "GPLv2.1"
LIC_FILES_CHKSUM = "file://COPYING;md5=7fbc338309ac38fefcd64b04bb903e34"

DEPENDS += " perl"

inherit debian-squeeze autotools
