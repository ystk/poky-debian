#
# debian-squeeze
#

DESCRIPTION = "Daemon to use a Hardware TRNG"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"
SECTION = "utils"
PR = "r0"

inherit autotools gettext

inherit debian-squeeze
