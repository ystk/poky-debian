#
# debian-squeeze
#

DESCRIPTION = "Utilities for sensible alternative selection"
SECTION = "utils"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://missing;beginline=1;endline=26;md5=9c91bb3aabb1fdfdd8632258ef337be8"
PR = "r0"

inherit autotools
inherit debian-squeeze
