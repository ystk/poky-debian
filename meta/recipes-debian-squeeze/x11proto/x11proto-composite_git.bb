#
# debian-squeeze
#

DESCRIPTION = "X11 Composite extension wire protocol"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=f8cdfa47489609f305b91521f3a8803f"
SECTION = "x11"
PR = "r0"

inherit autotools
inherit debian-squeeze
