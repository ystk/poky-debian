#
# debian-squeeze
#

DESCRIPTION = "X11 Damage extension wire protocol"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=d5f5a2de65c3a84cbde769f07a769608"
SECTION = "x11"
PR = "r0"

inherit autotools
inherit debian-squeeze
