#
# debian-squeeze
#

DESCRIPTION = "X11 Video Mode extension wire protocol"
LICENSE = "GPLv3+"
LIC_FILES_CHKSUM = "file://COPYING;md5=499be2ff387a42f84628c35f311f1502"
SECTION = "x11"
PR = "r0"

inherit autotools
inherit debian-squeeze
