#
# debian-squeeze
#

DESCRIPTION = "X11 Xinerama extension wire protocol"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=3e397a5326c83d5d0ebf5b3f87163ac6"
SECTION = "x11"
PR = "r0"

inherit autotools
inherit debian-squeeze
