#
# debian-squeeze
#
DESCRIPTION = "Search engine library"
SECTION = "libs"
LICENSE = "MIT/X"
LIC_FILES_CHKSUM = "file://COPYING;md5=4325afd396febcb659c36b49533135d4"
inherit debian-squeeze
inherit autotools
DEPENDS += ""
