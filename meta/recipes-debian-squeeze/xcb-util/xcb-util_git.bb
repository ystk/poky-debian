
#
# debian-squeeze
#
DESCRIPTION = "utility libraries for X C Binding -- atom"
SECTION = "libdevel"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://xcb-util-common.h;md5=951b3a596d4d7a3f75258683d4c76c61"


inherit debian-squeeze
inherit autotools
DEPENDS += ""
