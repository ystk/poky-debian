#
# zeromq3_git.bb
#

require zeromq.inc

LIC_FILES_CHKSUM = "file://COPYING.LESSER;md5=ad8c3bd15d88ea9d4509fc89bebc915c"
