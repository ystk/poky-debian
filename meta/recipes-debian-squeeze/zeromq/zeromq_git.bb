#
# zeromq_git.bb
#

require zeromq.inc

LIC_FILES_CHKSUM = "file://COPYING.LESSER;md5=66ea8704398d7996daeacd2fbd2b9dbd"
